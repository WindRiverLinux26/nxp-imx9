require linux-yocto-nxp-imx9.inc

KBRANCH:nxp-imx9  = "v6.18/standard/nxp-sdk-6.18/nxp-soc"
